# Keil uVision project Project.uvproj, settings and files
target Project (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_MD
  c include: ..\Boot;..\Refer\inc;..\Refer\eMPL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Project
    ./: main.c
  group Boot
    ../Boot/: startup_stm32f10x_md.s
  group Refer
    ../Refer/src/: led.c wave.c delay.c sys.c ILI93xx.c mpu6050.c iic.c mpupc.c key.c adc.c uartprotocol.c uart.c Timer.c wifi.c
    ../Refer/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
