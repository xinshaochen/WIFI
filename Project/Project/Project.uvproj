# Keil uVision project Project.uvproj, settings and files
target Project (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_MD
  c include: ..\Boot;..\Refer\inc;..\Refer\eMPL
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Project
    ./: main.c
  group Boot
    ../Boot/: startup_stm32f10x_md.s
  group Refer
    ../Refer/src/: led.c wave.c delay.c sys.c ILI93xx.c mpu6050.c iic.c uartprotocol.c uart.c
    ../Refer/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
