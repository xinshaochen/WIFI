# IAR project LED.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: ..\Project; ..\Refer\inc; ..\Refer\src
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: LED.hex
  ILINK.IlinkOutputFile: LED.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Project
    ./: main.c
  group Refer
    ../Refer/src/: 24l01.c ADC.c delay.c eeprom.c EXIT.c led.c motor.c remote.c time.c uart.c uartprotocol.c
